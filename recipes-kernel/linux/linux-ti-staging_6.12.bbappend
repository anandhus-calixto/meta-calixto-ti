KERNEL_GIT_URI = "git://github.com/eaglelinuxplatform/calixto-ti-linux.git"
BRANCH = "6.12.y"
SRCREV = "7ac196e81ad4354aa66abc46c43fb566959e4cff"
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}-6.12:"
