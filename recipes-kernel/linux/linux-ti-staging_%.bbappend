FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " file://am335x-calixto-nxt512.patch"
