UBOOT_GIT_URI = "git://github.com/eaglelinuxplatform/calixto-ti-uboot.git"

BRANCH = "2025.01"

SRCREV_uboot = "95cd3e931f1324cfac454bc060e320e021c94175"


