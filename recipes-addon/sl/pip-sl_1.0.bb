# The is automatic generated Code by "makePipRecipes.py"
# (build by Robin Sebastian (https://github.com/robseb) (git@robseb.de) Vers.: 1.2) 

SUMMARY = "Recipe to embedded the Python PiP Package sl"
HOMEPAGE ="https://pypi.org/project/sl"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://setup.py;md5=69b598488e4e0261f6d6c6f84a98f12c"

inherit pypi setuptools3
PYPI_PACKAGE = "sl"
SRC_URI[md5sum] = "2b3bdca80cff14dd6b59c30a4280a396"
SRC_URI[sha256sum] = "b716028262192131181eb70730827b91ebf93e35a9130caf976925b5ef69cf4f"
